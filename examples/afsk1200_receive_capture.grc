<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>afsk1200_receive_capture</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1,samp_rate, samp_rate/2, 50000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>center</value></param>
<param><key>label</key><value>center</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>24500 - 160</value></param>
<param><key>gui_hint</key><value>7,0,2,2</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>decode_gain</value></param>
<param><key>label</key><value>decode gain</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>7,2,2,2</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>Center Freq</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>rx_freq_param</value></param>
<param><key>gui_hint</key><value>6,0,2,2</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>rx_gain_param</value></param>
<param><key>gui_hint</key><value>6,2,2,2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>af_gain_param</value></param>
<param><key>value</key><value>0.7</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>decode_gain</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate * 3</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>filter_taps</value></param>
<param><key>center_freq</key><value>center</value></param>
<param><key>samp_rate</key><value>samp_rate </value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0</value></param>
<param><key>num_taps</key><value>65</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>25e3</value></param>
<param><key>width</key><value>1500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>ymin</key><value>-130</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>441</value></param>
<param><key>decim</key><value>1000</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq_param</value></param>
<param><key>value</key><value>445e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain_param</value></param>
<param><key>value</key><value>5</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab_main</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>num_tabs</key><value>2</value></param>
<param><key>label0</key><value>FFT</value></param>
<param><key>label1</key><value>Audio</value></param>
<param><key>gui_hint</key><value>0,0,10,10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>target_ip</value></param>
<param><key>value</key><value>192.168.20.100</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>target_port</value></param>
<param><key>value</key><value>1200</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>vtgs_afskdemod</key>
<param><key>id</key><value>vtgs_afskdemod_0</value></param>
<param><key>samp_sym</key><value>18</value></param>
<param><key>baud</key><value>1200</value></param>
<param><key>mark_f</key><value>1200</value></param>
<param><key>space_f</key><value>2200</value></param>
</block>
<block>
<key>vtgs_ax25_deframer</key>
<param><key>id</key><value>vtgs_ax25_deframer_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/pudavid/Programming/satcom/other/waveforms/afsk1200/rx/capture.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>hilbert_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>vtgs_afskdemod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vtgs_afskdemod_0</source_block_id><sink_block_id>vtgs_ax25_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vtgs_ax25_deframer_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>valid_frames</source_key><sink_key>print</sink_key></connection>
</flow_graph>
